# IAR project DeYan_UAV.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432E401Y TexasInstruments MSP432E401Y
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -I$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/CMSIS/Include; -DDeviceFamily_MSP432E4; -D__MSP432E401Y__; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050; -IApplication/Inc; -IDrive/Inc; -IDrive/Vl53l0x/Inc; -IFlyControl_Algorithm/Inc; -IFlyControl_Calculate/Inc
  ICCARM.CCIncludePath2: $PROJ_DIR$; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DeviceFamily_MSP432E4; __MSP432E401Y__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: DeYan_UAV.bin
  ILINK.IlinkOutputFile: DeYan_UAV.out
  ILINK.IlinkIcfFile: msp432e401y.icf
  ILINK.IlinkExtraOptions: $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4f; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4f/grlib.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4f/spiffs.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_msp432e4.arm4f; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/third_party/fatfs/lib/iar/m4f/fatfs.a; $SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/source/ti/devices/msp432e4/driverlib/lib/iar/m4f/msp432e4_driverlib.a; --silent; --cpu=Cortex-M4F; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
  ILINK.IlinkAdditionalLibs: Library\DeYan_UAV.a; FlyControl_Algorithm\FlyControl_Algorithm.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: common.h msp432e401y.icf startup_msp432e401y_ewarm.c system_msp432e401y.c
  group Application
    Application/Src/: BSP_Init.c DY_DT.c DY_Flight_Log.c DY_OF.c DY_Parameter.c DY_power.c DY_RC.c DY_Scheduler.c DY_Tracking.c main.c OpticalFlow.c
    Application/Inc/: include.h
  group Drive
    Drive/Src/: Drv_adc.c Drv_ak8975.c Drv_icm20602.c Drv_led.c Drv_pwm_in.c Drv_pwm_out.c Drv_soft_i2c.c Drv_spi.c Drv_spl06.c Drv_time.c Drv_usart.c Drv_vl53l0x.c Drv_w25qxx.c uartstdio.c
  group Drive_Vl53l0x
    Drive/Vl53l0x/Src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c.c vl53l0x_platform.c
  group FlyControl_Algorithm
    FlyControl_Algorithm/: FlyControl_Algorithm.a
  group FlyControl_Calculate
    FlyControl_Calculate/Inc/: config.h
    FlyControl_Calculate/Src/: DY_AltCtrl.c DY_AttCtrl.c DY_FlightCtrl.c DY_FlightDataCal.c DY_LocCtrl.c DY_MagProcess.c DY_MotorCtrl.c
  group Note
    Note/: Note.txt Pin_map.txt
